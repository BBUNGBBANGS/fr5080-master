# Keil uVision project 5080_btdm_audio.uvprojx, settings and files
target btdm_demo (6180000::V6.18::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: 5080_basic_function
  AfterMake: fromelf.exe  --text  -c -o Output/5080_basic_function.txt  Objects/5080_basic_function.axf
  AfterMake: fromelf.exe  --bin -o Output/5080_basic_function.bin  Objects/5080_basic_function.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c misc: --preinclude user_config.h
  c include: ..\code;..\..\..\..\components\modules\aes\api;..\..\..\..\components\modules\button;..\..\..\..\components\modules\common\api;..\..\..\..\components\modules\os;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\ipc;..\..\..\..\components\modules\fs;..\..\..\..\components\modules\dsp_program;..\..\..\..\components\btdm\include;..\..\..\..\components\btdm\profiles\ble_simple_profile;..\..\..\..\components\btdm\profiles\ble_ota;..\..\..\..\components\driver\include;..\..\..\..\components\driver\usb;..\..\..\..\components\driver\usb\usb_device_u_disc;..\..\..\..\components\modules\mp3_tag
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\5080_btdm_audio.sct
  link misc: ../../../../components/btdm/library/syscall.txt --entry=app_entry  --datacompressor=off --no-shortveneer
  group user
    ../code/: proj_main.c ble_simple_peripheral.c app_at.c user_task.c user_bt.c user_dsp.c user_fs.c audio_source.c native_playback.c mp3_sample.c msbc_playback.c comm.c
    ../../../../components/modules/dsp_program/: dsp_program.c
    ../../../../components/modules/common/api/: co_log.h
  group lib
    ../../../../components/btdm/library/: 5080_host.lib
  group boot
    ../../../../components/modules/platform/src/: app_boot_vectors.s hardfault.c
  group profile
    ../../../../components/btdm/profiles/ble_simple_profile/: simple_gatt_service.c
    ../../../../components/btdm/profiles/ble_ota/: ota_service.c ota.c
  group driver
    ../../../../components/driver/: driver_uart.c driver_pmu.c driver_gpio.c driver_i2c.c driver_i2s.c driver_timer.c driver_pdm.c driver_ipc.c driver_syscntl.c driver_wdt.c driver_codec.c driver_efuse.c driver_adc.c driver_flash_ssp.c driver_ssp.c driver_sdc.c usb_core.c usb_dev.c usb_audio.c
  group module
    ../../../../components/modules/ipc/: ipc_load_code.c
    ../../../../components/modules/print/: co_printf.c
    ../../../../components/modules/mp3_tag/: mp3_tag_decoder.c
    ../../../../components/modules/common/: user_util.c
  group usb
    ../../../../components/driver/usb/usb_device_u_disc/: usbdev.c usbmass.c mass_mal.c memory.c usb_bot.c usb_scsi.c scsi_data.c
    ../../../../components/driver/usb/: usb.c
  group fs
    ../../../../components/modules/fs/: diskio.c ff.c ffsystem.c ffunicode.c
target usb_host (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: 5080_basic_function
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\code;..\..\..\..\components\modules\aes\api;..\..\..\..\components\modules\button;..\..\..\..\components\modules\common\api;..\..\..\..\components\modules\os;..\..\..\..\components\modules\platform\include;..\..\..\..\components\btdm\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\sys\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\5080_bt_profile.sct
  link misc: ../../../../components/btdm/library/syscall.txt --entry=app_entry  --datacompressor=off
