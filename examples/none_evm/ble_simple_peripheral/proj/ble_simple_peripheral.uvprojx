# Keil uVision project ble_simple_peripheral.uvprojx, settings and files
target ble_simple_peripheral (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: 5080_basic_function
  AfterMake: fromelf.exe  --text  -c -o Output/5080_basic_function.txt  Objects/5080_basic_function.axf
  AfterMake: fromelf.exe  --bin -o Output/5080_basic_function.bin  Objects/5080_basic_function.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\code;..\..\..\..\components\modules\aes\api;..\..\..\..\components\modules\button;..\..\..\..\components\modules\common\api;..\..\..\..\components\modules\os;..\..\..\..\components\modules\platform\include;..\..\..\..\components\btdm\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\fs;..\..\..\..\components\modules\sys\include;..\..\..\..\components\btdm\profiles\ble_simple_profile
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_simple_peripheral.sct
  link misc: ../../../../components/btdm/library/syscall.txt --entry=app_entry  --datacompressor=off --no-shortveneer
  group user
    ../code/: proj_main.c app_at.c user_task.c ble_simple_peripheral.c
  group lib
    ../../../../components/btdm/library/: 5080_host.lib
  group boot
    ../../../../components/modules/platform/src/: app_boot_vectors.s hardfault.c
  group profile
    ../../../../components/btdm/profiles/ble_simple_profile/: simple_gatt_service.c
  group driver
    ../../../../components/driver/: driver_uart.c driver_pmu.c driver_ipc.c driver_syscntl.c
target usb_host (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: 5080_basic_function
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\code;..\..\..\..\components\modules\aes\api;..\..\..\..\components\modules\button;..\..\..\..\components\modules\common\api;..\..\..\..\components\modules\os;..\..\..\..\components\modules\platform\include;..\..\..\..\components\btdm\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\sys\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\5080_bt_profile.sct
  link misc: ../../../../components/btdm/library/syscall.txt --entry=app_entry  --datacompressor=off
